# IAR project nRF51_Goose_Data.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf51422_xxac NordicSemi nrf51422_xxac
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; NRF51822; BOARD_PCA10028; S130; NRF_SD_BLE_API_VERSION=2; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF51DK
  ICCARM.CCIncludePath2: ..\Library\device; ..\Library\toolchain; ..\Library\toolchain\cmsis\include; ..\Library\softdevice\s130\headers; ..\Library\softdevice\s130\headers\nrf51; ..\Library\softdevice\common\softdevice_handler; ..\Library\ble\ble_advertising; ..\Library\ble\common; ..\Library\device; ..\Library\drivers_nrf\clock; ..\Library\drivers_nrf\common; ..\Library\drivers_nrf\delay; ..\Library\drivers_nrf\hal; ..\Library\drivers_nrf\gpiote; ..\Library\drivers_nrf\nrf_soc_nosd; ..\Library\drivers_nrf\ppi; ..\Library\drivers_nrf\timer; ..\Library\drivers_nrf\twi_master; ..\Library\drivers_nrf\uart; ..\Library\libraries\button; ..\Library\libraries\fds; ..\Library\libraries\fstorage; ..\Library\libraries\gpiote; ..\Library\libraries\log; ..\Library\libraries\log\src; ..\Library\libraries\pwm; ..\Library\libraries\scheduler; ..\Library\libraries\timer; ..\Library\libraries\twi; ..\Library\libraries\util; ..\Users\Main; ..\Library\drivers_nrf\power; ..\Library\drivers_nrf\rng; ..\Library\libraries\queue; ..\Library\boards; D:\Workspace\NRF51_Goose_Data\Library\drivers_nrf\spi_master; ..\Library\drivers_nrf\hal; ..\Library\drivers_nrf\common; ..\Library\drivers_nrf\clock; ..\Library\drivers_nrf; ..\Library\drivers_nrf\uart; ..\Users\App\Uart; ..\Library\drivers_nrf\hal; ..\Users\App\Global; ..\Users\App\SPI_Flash; ..\Users\App\Goose_IIC_Init; ..\Users\App\PCF8563; ..\Users\App\Soft_IIC; ..\Users\App\BLE; ..\Users\App\BLE_Services; ..\Library\softdevice\s130\headers; ..\Library\softdevice\common\softdevice_handler; ..\Users\App; ..\Library\ble\ble_advertising; ..\Library\ble\nrf_ble_gatt; ..\Library\ble\common; ..\Library\ble\ble_advertising; ..\Library\ble\common; ..\Library\ble\nrf_ble_gatt; ..\Library\libraries\trace; ..\Library\drivers_nrf\pstorage; ..\Library\drivers_nrf\pstorage\config; ..\Library\softdevice\common\softdevice_handler; ..\Users\Main; ..\Library\toolchain\cmsis; ..\Library\toolchain\cmsis\include; ..\Library\toolchain; ..\Library\softdevice; ..\Library\softdevice\s130\headers; ..\Library\softdevice\s130\headers\nrf51; ..\Library\softdevice\common; ..\Library\softdevice\common\softdevice_handler; ..\Library\libraries\bsp; ..\Library\libraries\scheduler; ..\Library\libraries\scheduler
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: nRF51_Goose_Data.srec
  ILINK.IlinkOutputFile: nRF51_Goose_Data.out
  ILINK.IlinkIcfFile: D:\Workspace\NRF51_Goose_Data\Users\Main\iar_s130_nrf51422_xxac.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/BLE_Init
    ../Users/App/BLE/: BLE_Init.c BLE_Init.h
  group App/BLE_Services
    ../Users/App/BLE_Services/: Goose_RTC_Service.c Goose_RTC_Service.h
  group App/Global
    ../Users/App/Global/: Global.c Global.h Global_Typedef.h
  group App/Goose_IIC_Init
    ../Users/App/Goose_IIC_Init/: Goose_IIC_Init.c Goose_IIC_Init.h
  group App/KH25V1635F_Driver
    ../Users/App/SPI_Flash/: KH25V1635F_Driver.c KH25V1635F_Driver.h
  group App/PCF8563_Driver
    ../Users/App/PCF8563/: PCF8563_Driver.c PCF8563_Driver.h
  group App/Store_History_Data
    ../Users/App/SPI_Flash/: KH25_Flash_Store.c KH25_Flash_Store.h
  group App/SW_IIC
    ../Users/App/Soft_IIC/: SW_IIC.c SW_IIC.h
  group App/Uart
    ../Users/App/Uart/: simple_uart.c Simple_uart.h
  group Library/App_Scheduler
    ../Library/libraries/scheduler/: app_scheduler.c App_scheduler.h app_scheduler_dox_config.h
  group Library/App_Timer
    ../Library/libraries/timer/: app_timer.c App_timer.h app_timer_appsh.c App_timer_appsh.h
  group Library/App_Trace
    ../Library/libraries/trace/: app_trace.c app_trace.h
  group Library/BLE
    ../Library/ble/ble_advertising/: ble_advertising.c ble_advertising.h
  group Library/BLE_Common
    ../Users/App/common/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h ble_conn_state.c ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.c ble_srv_common.h
  group Library/Boards
    ../Library/boards/: boards.c boards.h pca10028.h
    ../Library/libraries/bsp/: bsp.c bsp.h
  group Library/Device
    ../Library/device/: compiler_abstraction.h nrf.h nrf51.h nrf51822_peripherals.h nrf51_bitfields.h nrf51_deprecated.h
  group Library/nRF_Drivers/Clock
    ../Library/drivers_nrf/clock/: nrf_drv_clock.c nrf_drv_clock.h nrf_drv_clock_dox_config.h
  group Library/nRF_Drivers/Common
    ../Library/drivers_nrf/common/: nrf_drv_common.c nrf_drv_common.h nrf_drv_common_dox_config.h
  group Library/nRF_Drivers/HAL
    ../Library/drivers_nrf/hal/: nrf_spi.h nrf_spim.h nrf_spis.h nrf_uart.h
  group Library/nRF_Drivers/Power
    ../Library/drivers_nrf/power/: nrf_drv_power.c nrf_drv_power.h nrf_drv_power_dox_config.h
  group Library/nRF_Drivers/pStrorage
    ../Library/drivers_nrf/pstorage/: pstorage.c pstorage.h
  group Library/nRF_Drivers/pStrorage/Config
    ../Library/drivers_nrf/pstorage/config/: pstorage_platform.h
  group Library/nRF_Drivers/SPI
    ../Library/drivers_nrf/spi_master/: nrf_drv_spi.c Nrf_drv_spi.h nrf_drv_spi_dox_config.h
  group Library/nRF_Drivers/Timer
    ../Library/drivers_nrf/timer/: nrf_drv_timer.c nrf_drv_timer.h nrf_drv_timer_dox_config.h
  group Library/nRF_Drivers/Uart
    ../Library/drivers_nrf/uart/: nrf_drv_uart.c nrf_drv_uart.h nrf_drv_uart_dox_config.h
  group Library/ToolChain
    ../Library/toolchain/: system_nrf51.c system_nrf51.h
  group Library/ToolChain/CMSIS/Include
    ../Library/toolchain/cmsis/include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Library/util
    ../Library/libraries/util/: app_error.c app_error.h app_error_weak.c app_error_weak.h app_util.h app_util_bds.h app_util_platform.c app_util_platform.h nordic_common.h nrf_assert.c nrf_assert.h nrf_bitmask.h sdk_common.h sdk_errors.c sdk_errors.h sdk_macros.h sdk_mapped_flags.c sdk_mapped_flags.h sdk_os.h sdk_resources.h
  group Main
    ../Users/Main/: iar_s130_nrf51422_xxac.icf iar_startup_nrf51.s main.c sdk_config.h
  group Soft_Device
    ../Library/softdevice/s130/headers/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
  group Soft_Device/Common
    ../Library/softdevice/common/softdevice_handler/: ant_stack_handler_types.h softdevice_handler.c softdevice_handler.h
    ../../nRF51_SDK/components/softdevice/common/softdevice_handler/: app_ram_base.h ble_stack_handler_types.h softdevice_handler_appsh.c softdevice_handler_appsh.h
