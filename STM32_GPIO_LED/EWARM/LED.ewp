# IAR project LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Library\FWlib\inc; Library\CMSIS\iar; Library\CMSIS; Users; Library\FWlib\srs; ..\Users\app; ..\Users\main; ..\Library\FWlib\srs; ..\Library\FWlib\inc; ..\Library\CMSIS; ..\Library\CMSIS\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.srec
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Library/CMSIS/: misc.c misc.h system_stm32f10x.c system_stm32f10x.h
  group FWlib
    ../Library/FWlib/srs/: stm32f10x_gpio.c stm32f10x_rcc.c
    ../Library/FWlib/inc/: stm32f10x_gpio.h stm32f10x_rcc.h
  group STARTUP
    ../Library/CMSIS/iar/: startup_stm32f10x_hd.s
  group USERS/app
    ../Users/app/: Led.c Led.h
  group USERS/main
    ../Users/main/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
