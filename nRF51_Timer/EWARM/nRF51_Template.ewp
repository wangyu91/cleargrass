# IAR project nRF51_Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf51822_xxac NordicSemi nrf51822_xxac
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; BLE_STACK_SUPPORT_REQD; NRF51822; S130; NRF51; NRF_SD_BLE_API_VERSION=2; SOFTDEVICE_PRESENT; BOARD_PCA10028
  ICCARM.CCIncludePath2: ..\Library\device; ..\Library\toolchain; ..\Library\toolchain\cmsis\include; ..\Library\softdevice\s130\headers; ..\Library\softdevice\s130\headers\nrf51; ..\Library\softdevice\common\softdevice_handler; ..\Library\ble\ble_advertising; ..\Library\ble\common; ..\Library\device; ..\Library\drivers_nrf\clock; ..\Library\drivers_nrf\common; ..\Library\drivers_nrf\delay; ..\Library\drivers_nrf\hal; ..\Library\drivers_nrf\gpiote; ..\Library\drivers_nrf\nrf_soc_nosd; ..\Library\drivers_nrf\ppi; ..\Library\drivers_nrf\timer; ..\Library\drivers_nrf\twi_master; ..\Library\drivers_nrf\uart; ..\Library\libraries\button; ..\Library\libraries\fds; ..\Library\libraries\fstorage; ..\Library\libraries\gpiote; ..\Library\libraries\log; ..\Library\libraries\log\src; ..\Library\libraries\pwm; ..\Library\libraries\scheduler; ..\Library\libraries\timer; ..\Library\libraries\twi; ..\Library\libraries\util; ..\Users\Main; ..\Library\drivers_nrf\power; ..\Library\drivers_nrf\rng; ..\Library\libraries\queue; ..\Users\App\simple_timer; ..\Library\boards
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: nRF51_Template.srec
  ILINK.IlinkOutputFile: nRF51_Template.out
  ILINK.IlinkIcfFile: D:\Workspace\nRF51_Timer\Users\Main\simple_timer_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../Users/App/simple_timer/: app_simple_timer.c app_simple_timer.h app_simple_timer_dox_config.h
  group LIbrary/BLE/Common
    ../Library/ble/common/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h ble_conn_state.c ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.c ble_srv_common.h
    ../Library/ble/ble_advertising/: ble_advertising.c ble_advertising.h ble_advertising_dox_config.h
  group LIbrary/Boards
    ../Library/boards/: boards.c boards.h pca10028.h
  group LIbrary/Device
    ../Library/device/: compiler_abstraction.h nrf.h nrf51.h nrf51822_peripherals.h nrf51_bitfields.h nrf51_deprecated.h
  group LIbrary/Drivers_NRF/Clock
    ../Library/drivers_nrf/clock/: nrf_drv_clock.c nrf_drv_clock.h nrf_drv_clock_dox_config.h
  group LIbrary/Drivers_NRF/Common
    ../Library/drivers_nrf/common/: nrf_drv_common.c nrf_drv_common.h nrf_drv_common_dox_config.h
  group LIbrary/Drivers_NRF/Delay
    ../Library/drivers_nrf/delay/: nrf_delay.h
  group LIbrary/Drivers_NRF/Hal
    ../Library/drivers_nrf/hal/: nrf_adc.c nrf_adc.h nrf_clock.h
  group LIbrary/Drivers_NRF/NRF_GPIOTE
    ../Library/drivers_nrf/gpiote/: nrf_drv_gpiote.c nrf_drv_gpiote.h nrf_drv_gpiote_dox_config.h
  group LIbrary/Drivers_NRF/NRF_SOC_NOSD
    ../Library/drivers_nrf/nrf_soc_nosd/: nrf_error.h nrf_nvic.c nrf_nvic.h nrf_soc.c nrf_soc.h
  group LIbrary/Drivers_NRF/Power
    ../Library/drivers_nrf/power/: nrf_drv_power.c nrf_drv_power.h nrf_drv_power_dox_config.h
  group LIbrary/Drivers_NRF/PPI
    ../Library/drivers_nrf/ppi/: nrf_drv_ppi.c nrf_drv_ppi.h nrf_drv_ppi_dox_config.h
  group LIbrary/Drivers_NRF/RNG
    ../Library/drivers_nrf/rng/: nrf_drv_rng.c nrf_drv_rng.h nrf_drv_rng_dox_config.h
  group LIbrary/Drivers_NRF/Timer
    ../Library/drivers_nrf/timer/: nrf_drv_timer.c nrf_drv_timer.h nrf_drv_timer_dox_config.h
  group LIbrary/Drivers_NRF/TWI_Master
    ../Library/drivers_nrf/twi_master/: nrf_drv_twi.c nrf_drv_twi.h nrf_drv_twi_dox_config.h
  group LIbrary/Drivers_NRF/Uart
    ../Library/drivers_nrf/uart/: nrf_drv_uart.c nrf_drv_uart.h nrf_drv_uart_dox_config.h
  group LIbrary/LIb/Button
    ../Library/libraries/button/: app_button.c app_button.h app_button_dox_config.h
  group LIbrary/LIb/Flash
    ../Library/libraries/fds/: fds.c fds.h fds_dox_config.h fds_internal_defs.h
    ../Library/libraries/fstorage/: fstorage.c fstorage.h fstorage_dox_config.h fstorage_internal_defs.h
  group LIbrary/LIb/GPIOTE
    ../Library/libraries/gpiote/: app_gpiote.c app_gpiote.h app_gpiote_dox_config.h
  group LIbrary/LIb/Log
    ../Library/libraries/log/: nrf_log.h nrf_log_backend.h nrf_log_backend_dox_config.h nrf_log_ctrl.h nrf_log_dox_config.h
  group LIbrary/LIb/Log/src
    ../Library/libraries/log/src/: nrf_log_backend_serial.c nrf_log_ctrl_internal.h nrf_log_frontend.c nrf_log_internal.h
  group LIbrary/LIb/PWM
    ../Library/libraries/pwm/: app_pwm.c app_pwm.h app_pwm_dox_config.h
  group LIbrary/LIb/Queue
    ../Library/libraries/queue/: nrf_queue.c nrf_queue.h nrf_queue_dox_config.h
  group LIbrary/LIb/Scheduler
    ../Library/libraries/scheduler/: app_scheduler.c app_scheduler.h app_scheduler_dox_config.h
  group LIbrary/LIb/Timer
    ../Library/libraries/timer/: app_timer.c app_timer.h app_timer_appsh.c app_timer_appsh.h
  group LIbrary/LIb/TWI
    ../Library/libraries/twi/: app_twi.c app_twi.h app_twi_dox_config.h
  group LIbrary/LIb/Util
    ../Library/libraries/util/: app_error.c app_error.h app_error_weak.c app_error_weak.h app_util.h app_util_bds.h app_util_platform.c app_util_platform.h nordic_common.h nrf_assert.c nrf_assert.h nrf_bitmask.h sdk_common.h sdk_errors.c sdk_errors.h sdk_macros.h sdk_mapped_flags.c sdk_mapped_flags.h sdk_os.h sdk_resources.h
  group LIbrary/SoftDevice/Common/SoftDevice_Handler
    ../Library/softdevice/common/softdevice_handler/: app_ram_base.h ble_stack_handler_types.h softdevice_handler.c softdevice_handler.h softdevice_handler_appsh.c softdevice_handler_appsh.h
  group LIbrary/SoftDevice/S130/Headers
    ../Library/softdevice/s130/headers/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
  group LIbrary/SoftDevice/S130/Headers/NRF51
    ../Library/softdevice/s130/headers/nrf51/: nrf_mbr.h
  group LIbrary/Tool_Chain
    ../Library/toolchain/: system_nrf51.c system_nrf51.h
  group LIbrary/Tool_Chain/CMSIS/include
    ../Library/toolchain/cmsis/include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Main
    ../Users/Main/: iar_nrf51_blank_xxac.icf iar_startup_nrf51.s main.c sdk_config.h
