# IAR project History_Data.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\User\Main; ..\User\App\Example_uart; ..\User\App\Soft_IIC; ..\Library\FWlib\inc; ..\Library\FWlib\srs; ..\Library\CMSIS; ..\Library\CMSIS\iar; ..\User\App\Global; ..\User\App\Goose_IIC_Init; ..\User\App\PCF8563
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: History_Data.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/Global
    ../User/App/Global/: Global.c Global.h
  group App/Goose_IIC_Init
    ../User/App/Goose_IIC_Init/: Goose_IIC_Init.c Goose_IIC_Init.h
  group App/PCF8563_Driver
    ../User/App/PCF8563/: PCF8563_Driver.c PCF8563_Driver.h
  group App/SW_IIC
    ../User/App/Soft_IIC/: SW_IIC.c SW_IIC.h
  group App/Uart
    ../User/App/Example_uart/: bsp_usart1.c bsp_usart1.h
  group Library/CMSIS
    ../Library/CMSIS/: misc.c misc.h system_stm32f10x.c system_stm32f10x.h
  group Library/FWlib/inc
    ../Library/FWlib/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group Library/FWlib/srs
    ../Library/FWlib/srs/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group main
    ../User/Main/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group StartUp
    ../Library/CMSIS/iar/: startup_stm32f10x_hd.s
