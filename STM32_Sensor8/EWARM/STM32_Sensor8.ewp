# IAR project STM32_Sensor8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Library\CMSIS\iar; ..\Library\CMSIS; ..\Library\FWlib\inc; ..\Library\FWlib\srs; ..\Users\main; ..\Users\app; ..\Users\App\Global; ..\Users\App\Soft_IIC; ..\Users\App\GPIO_LED; ..\Users\App\Global; ..\Users\App\SHT30_Driver; ..\Users\App\Example_uart; ..\Users\App\Sensor8_IIC_Init; ..\Users\App\BH172
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32_Sensor8.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Library/CMSIS
    ../Library/CMSIS/: misc.c misc.h system_stm32f10x.c system_stm32f10x.h
  group Library/FWlib
    ../Library/FWlib/srs/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ../Library/FWlib/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group STARTUP
    ../Library/CMSIS/iar/: startup_stm32f10x_hd.s
  group users/App/BH1721
    ../Users/App/BH172/: BH1721_Driver.c BH1721_Driver.h
  group users/App/Example_Uart
    ../Users/App/Example_uart/: bsp_usart1.c bsp_usart1.h
  group users/App/Global
    ../Users/App/Global/: Global.c Global.h
  group users/App/GPIO_LED
    ../Users/App/GPIO_LED/: GPIO_LED.c GPIO_LED.h
  group users/App/Sensor8_IIC_Init
    ../Users/App/Sensor8_IIC_Init/: Sensor8_IIC_Init.c Sensor8_IIC_Init.h Sensor8_IIC_Init1.c Sensor8_IIC_Init1.h Sensor8_IIC_Init2.c Sensor8_IIC_Init2.h Sensor8_IIC_Init3.c Sensor8_IIC_Init3.h Sensor8_IIC_Init4.c Sensor8_IIC_Init4.h Sensor8_IIC_Init5.c Sensor8_IIC_Init5.h Sensor8_IIC_Init6.c Sensor8_IIC_Init6.h Sensor8_IIC_Init7.c Sensor8_IIC_Init7.h
  group users/App/SHT
    ../Users/App/SHT30_Driver/: SHT30_Driver.c SHT30_Driver.h SHT30_Init.c SHT30_Init.h
  group users/App/SW_IIC
    ../Users/App/Soft_IIC/: SW_IIC.c SW_IIC.h
  group users/main
    ../Users/Main/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
